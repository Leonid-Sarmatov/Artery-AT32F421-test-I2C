# Keil uVision project project_0.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: -AT32F421F8P7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: project_0 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.0, Device:at32f421_conf 2.0.0, Device:at32f421_firmware_library:adc 2.0.0, Device:at32f421_firmware_library:crm 2.0.0, Device:at32f421_firmware_library:ertc 2.0.0, Device:at32f421_firmware_library:gpio 2.0.0, Device:at32f421_firmware_library:i2c 2.0.0, Device:at32f421_firmware_library:misc 2.0.0, Device:at32f421_firmware_library:tmr 2.0.0, Device:at32f421_firmware_library:wdt 2.0.0
